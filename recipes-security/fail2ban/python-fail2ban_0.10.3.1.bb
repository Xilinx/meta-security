inherit setuptools
require python-fail2ban.inc
