inherit setuptools3
require python-fail2ban.inc
