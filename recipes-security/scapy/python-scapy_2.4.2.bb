inherit setuptools
require python-scapy.inc

RDEPENDS_${PN} += "${PYTHON_PN}-subprocess"
