inherit setuptools3
require python-scapy.inc
